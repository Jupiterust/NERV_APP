# Keil uVision project test.uvprojx, settings and files
target Target_1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F470VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: GD32F470,NDEBUG,MB_POINT_MAP_ENABLE
  c include: ..\Libraries\Include;..\Startup;..\System;..\User;..\FatFt;..\Headfile;..\Driver;..\Function;..\Protocol;..\Driver\Rom;..\Driver\Usart;..\Function\App_upgrade;..\Function\bootloader;..\Driver\BootConfig;..\Protocol\Custom_Protocol;..\Protocol\Free_Modbus;..\Protocol\Free_Modbus\ascii;..\Protocol\Free_Modbus\functions;..\Protocol\Free_Modbus\include;..\Protocol\Free_Modbus\port;..\Protocol\Free_Modbus\rtu
  library: MicroLIB
  memory RVCT4: ROM 0x8011000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../Startup/: startup_gd32f450_470.s
  group System
    ../System/: system_gd32f4xx.c
  group Libraries
    ../Libraries/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group Driver
    ../Driver/: bsp_ADC.c bsp_dac.c bsp_debug.c bsp_flash.c bsp_GD30AD3344.c bsp_led.c bsp_oled.c bsp_rs485.c bsp_sys.c bsp_rtc.c bsp_wkp.c bsp_general_timer.c bsp_sdio.c bsp_key.c
    ../Driver/Usart/: appupgrade_usart.c
    ../Driver/Rom/: rom.c
    ../Driver/BootConfig/: BootConfig.c
  group Headfile
    ../Headfile/: Headfile.h
    ./: README.txt
  group User
    ../User/: gd32f4xx_it.c main.c systick.c
  group Fatft
    ../FatFt/: diskio.c ff.c sdcard.c
  group Function
    ../Function/: Function.c Log_recording_function.c Op_log_function.c param_handle.c modbus_data_map.c file_service.c
    ../Function/bootloader/: bootloader.c
    ../Function/App_upgrade/: app_upgrade.c
  group Protocol
    ../Protocol/Custom_Protocol/: General_Protocol.c
    ../Protocol/: Protocol_Router.c
    ../Protocol/Free_Modbus/: mb.c
    ../Protocol/Free_Modbus/ascii/: mbascii.c
    ../Protocol/Free_Modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../Protocol/Free_Modbus/port/: port.c portevent.c portserial.c porttimer.c
    ../Protocol/Free_Modbus/rtu/: mbcrc.c mbrtu.c
software components: CMSIS:CORE 6.2.0
